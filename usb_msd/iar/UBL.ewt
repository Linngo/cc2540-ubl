<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>CC2540-DK</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>CC2540-Nano</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\app\ubl_exec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\ubl_exec.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\ubl_ivec.s51</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ubl_link.xcl</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\ubl_main.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>USB</name>
      <group>
        <name>library</name>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_descriptor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_descriptor_parser.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_descriptor_parser.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_framework.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_framework.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_framework_structs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_interrupt.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\class_msd\usb_msd_8051.lib</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_reg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_standard_requests.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_standard_requests.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\hal\usb\library\usb_suspend.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\hal\usb\usb_board_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\hal\usb\usb_interrupt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\hal\usb\usb_suspend.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\hal\hal_board_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\hal\hal_defs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\hal\hal_dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\hal\hal_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\hal\hal_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\hal\hal_mcu.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\hal\hal_types.h</name>
    </file>
  </group>
</project>


